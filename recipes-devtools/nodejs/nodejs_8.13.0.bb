require nodejs_8.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=fde91d5c5bbd1e0389623e1ac018d9e8"

SRC_URI[src.md5sum] = "f5f64ec7c62b79272919723d6ac48e4f"
SRC_URI[src.sha256sum] = "9ba06fe4da9539721281bba4e21be0cd31546c4f47bbdccc21a9fca243e75083"
